# IAR project cc2650lp_app.ewp, settings and files
configuration FlashROM_TFT (ARM, debug)
  General.OGChipSelectEditMenu: CC2650F128 TexasInstruments CC2650F128
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: BOARD_DISPLAY_EXCLUDE_UART; CC2650MOD_RSM; CC26XX; Display_DISABLE_ALL; HEAPMGR_SIZE=0; ICALL_MAX_NUM_ENTITIES=6; ICALL_MAX_NUM_TASKS=3; xPOWER_SAVING; SDI_USE_UART; USE_ICALL; xBOARD_DISPLAY_EXCLUDE_LCD; xdc_runtime_Assert_DISABLE_ALL; xdc_runtime_Log_DISABLE_ALL; PROFILE_Multibyte; IOTXX_DISPLAY_TFT; MAX_PDU_SIZE=87
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: -f $SRC_EX$/config/build_components.opt; -f ..\stack\build_config.opt; -f ..\config\configPkg\compiler.opt.defs; -f ..\config\iar_boundary.bdef
  ICCARM.CCIncludePath2: $SRC_BLE_CORE$/controller/cc26xx/inc; $SRC_BLE_CORE$/inc; $SRC_EX$/common/cc26xx; $SRC_EX$/icall/inc; $SRC_EX$/inc; $SRC_EX$/profiles/dev_info; $SRC_EX$/profiles/roles; $SRC_EX$/profiles/roles/cc26xx; $SRC_COMMON$/hal/src/inc; $SRC_COMMON$/hal/src/target/_common; $SRC_COMMON$/hal/src/target/_common/cc26xx; $SRC_COMMON$/hal/src/target/cc2650/rom; $SRC_COMMON$/heapmgr; $SRC_COMMON$/icall/src/inc; $SRC_COMMON$/osal/src/inc; $SRC_COMMON$/services/src/saddr; $SRC_COMMON$/services/src/sdata; $CC26XXWARE$; $TI_RTOS_DRIVERS_BASE$; ..\..\source\app; ..\..\source\profile; ..\..\source\driver\uart; ..\..\source\driver\gpio; ..\..\..\common\display; C:\ti\simplelink\ble_sdk_2_02_01_18\examples\cc2650iot\target\LAUNCHIOT_CC2650_RSM; ..\..\source\sdi; ..\..\source\spi; ..\..\source\driver\adc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: simple_peripheral_cc2650lp_app.hex
  prebuild: "$XDCROOT$/xs" --xdcpath="$XDCPATH$" iar.tools.configuro -c "$TOOLKIT_DIR$" --cc "$COMPILER_PATH$" --device "$DEVICE$" --compileOptions $COMPILER_ARGS_ROOT_QUOTED$ --linkOptions $LINKER_ARGS_QUOTED$ --profile release --projFile "$PROJ_PATH$"
  ILINK.IlinkOutputFile: simple_peripheral_cc2650lp_app.out
  ILINK.IlinkIcfFile: $SRC_EX$/common/cc26xx/iar/cc26xx_app.icf
  ILINK.IlinkExtraOptions: --keep __vector_table; -f ..\config\configPkg\linker.cmd; -f ..\config\iar_boundary.xcl
  ILINK.IlinkAdditionalLibs: $ROM$\common_rom_releases\03282014\common_rom.symbols; $CC26XXWARE$\driverlib\bin\iar\driverlib.lib
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FlashROM_ePaper (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: BOARD_DISPLAY_EXCLUDE_UART; CC2650MOD_RGZ; CC26XX; xDisplay_DISABLE_ALL; HEAPMGR_SIZE=0; ICALL_MAX_NUM_ENTITIES=6; ICALL_MAX_NUM_TASKS=3; POWER_SAVING; USE_ICALL; xBOARD_DISPLAY_EXCLUDE_LCD; xdc_runtime_Assert_DISABLE_ALL; xdc_runtime_Log_DISABLE_ALL; PROFILE_Multibyte; IOTXX_DISPLAY_EPD
  ICCARM.CCIncludePath2: $SRC_BLE_CORE$/controller/cc26xx/inc; $SRC_BLE_CORE$/inc; $SRC_EX$/common/cc26xx; $SRC_EX$/icall/inc; $SRC_EX$/inc; $SRC_EX$/profiles/dev_info; $SRC_EX$/profiles/roles; $SRC_EX$/profiles/roles/cc26xx; $SRC_COMMON$/hal/src/inc; $SRC_COMMON$/hal/src/target/_common; $SRC_COMMON$/hal/src/target/_common/cc26xx; $SRC_COMMON$/hal/src/target/cc2650/rom; $SRC_COMMON$/heapmgr; $SRC_COMMON$/icall/src/inc; $SRC_COMMON$/osal/src/inc; $SRC_COMMON$/services/src/saddr; $SRC_COMMON$/services/src/sdata; $CC26XXWARE$; $TI_RTOS_DRIVERS_BASE$; ..\..\source\app; ..\..\source\profile; ..\..\source\driver\uart; ..\..\source\driver\gpio; ..\..\..\common\display; ..\..\..\target\LAUNCHIOT_CC2650_RGZ
  group Application
    ../../../../../src/common/cc26xx/rcosc/: rcosc_calibration.c rcosc_calibration.h
    ../../source/app/: simple_peripheral.c simple_peripheral.h
    ../../../../../src/common/cc26xx/: util.c util.h
  group Drivers/ADC
    ../../source/driver/adc/: hw_adc.c hw_adc.h
  group Drivers/Display
    $TI_RTOS_DRIVERS_BASE$/ti/mw/display/: Display.c Display.h DisplayUart.c DisplayUart.h
  group Drivers/ECC
    ../../../../../src/common/cc26xx/ecc/: ECCROMCC26XX.c ECCROMCC26XX.h
  group Drivers/PIN
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/: PIN.h
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/pin/: PINCC26XX.c PINCC26XX.h
  group Drivers/RF
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/rf/: RF.h RFCC26XX_singleMode.c
  group Drivers/SPI
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/: SPI.c SPI.h
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/spi/: SPICC26XXDMA.c SPICC26XXDMA.h
  group Drivers/TRNG
    ../../../../../src/components/hal/src/target/_common/: TRNGCC26XX.c TRNGCC26XX.h
  group Drivers/UDMA
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/dma/: UDMACC26XX.c UDMACC26XX.h
  group GY_SerialPort
    ../../source/driver/gpio/: hw_gpio.c
    ../../source/driver/uart/: task_uart.c task_uart.h
  group ICall
    ../../../../../src/components/heapmgr/: heapmgr.h
    ../../../../../src/components/icall/src/: icall.c icall_cc2650.c icall_platform.h
    ../../../../../src/components/icall/src/inc/: icall.h
    ../../../../../src/icall/inc/: icall_addrs.h
  group ICallBLE
    ../../../../../src/icall/app/: ble_user_config.c icall_api.c
    ../../../../../src/icall/inc/: ble_user_config.h icall_apimsg.h
  group Include
    ../../../../../src/inc/: gap.h gapgattserver.h gatt.h hci.h
    ../../../../../src/profiles/roles/: gapbondmgr.h
    ../../../../../src/components/osal/src/inc/: osal_snv.h
  group Middleware/extflash
    $TI_RTOS_DRIVERS_BASE$/ti/mw/extflash/: ExtFlash.c ExtFlash.h
  group Profiles
    ../../../../../src/profiles/dev_info/cc26xx/: devinfoservice.c
    ../../../../../src/profiles/dev_info/: devinfoservice.h
    ../../../../../src/inc/: gatt_profile_uuid.h gatt_uuid.h
    ../../../../../src/host/: gatt_uuid.c gattservapp_util.c
    ../../../../../src/profiles/roles/cc26xx/: peripheral.c peripheral.h
    ../../source/profile/: simple_gatt_profile.c simple_gatt_profile.h
  group SDI
    ../../source/sdi/: sdi_rxbuf.c sdi_task.c sdi_tl.c sdi_tl_uart.c
  group SPI
    ../../source/spi/: bsp.h bsp_spi.c bsp_spi.h ExtFlash.c ExtFlash.h oad_target.h oad_target_external_flash.c
  group Startup
    ../../../target/: board.c
    ../config/: ccfg_app_ble.c
    ../../../../../src/common/cc26xx/rcosc/: ccfg_app_ble_rcosc.c
    ../../source/app/: main.c
  group Tools
    ../config/: app_ble.cfg iar_boundary.bdef iar_boundary.xcl
    ../../../../../src/common/cc26xx/iar/: cc26xx_app.icf cc26xx_app_oad.icf

# IAR project cc2650lp_app.ewp, settings and files
configuration FlashROM (ARM, debug)
  General.OGChipSelectEditMenu: CC2650F128 TexasInstruments CC2650F128
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: MAX_NUM_BLE_CONNS=2; USE_ICALL; xPOWER_SAVING; SDI_USE_UART; HEAPMGR_SIZE=0; Display_DISABLE_ALL; BOARD_DISPLAY_EXCLUDE_UART; BOARD_DISPLAY_EXCLUDE_LCD; ICALL_MAX_NUM_TASKS=3; ICALL_MAX_NUM_ENTITIES=6; xdc_runtime_Assert_DISABLE_ALL; xdc_runtime_Log_DISABLE_ALL; CC2650MOD_RSM; CC26XX; IOTXX_DISPLAY_TFT; PROFILE_Multibyte; MAX_PDU_SIZE=87
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: -f $SRC_EX$/config/build_components.opt; -f ..\stack\build_config.opt; -f ..\config\configPkg\compiler.opt.defs; -f ..\config\iar_boundary.bdef
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\..\..\..\..\src\profiles\roles\cc26xx; $SRC_BLE_CORE$/controller/cc26xx/inc; $SRC_BLE_CORE$/inc; $SRC_EX$/common/cc26xx; $SRC_EX$/icall/inc; $SRC_EX$/inc; $SRC_EX$/profiles/dev_info; $SRC_EX$/profiles/roles/; $SRC_EX$/profiles/roles/cc26xx; $SRC_COMMON$/hal/src/inc; $SRC_COMMON$/hal/src/target/_common; $SRC_COMMON$/hal/src/target/_common/cc26xx; $SRC_COMMON$/heapmgr; $SRC_COMMON$/icall/src/inc; $SRC_COMMON$/osal/src/inc; $SRC_COMMON$/services/src/saddr; $SRC_COMMON$/services/src/sdata; $CC26XXWARE$; $TI_RTOS_DRIVERS_BASE$; ..\..\source\app; ..\..\source\profile; ..\..\source\driver\gpio; ..\..\..\common\display; ..\..\..\target\LAUNCHIOT_CC2650_RSM; ..\..\source\driver\uart; ..\..\source\spi; ..\..\source\matrix; ..\..\source\sdi
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: multi_role_cc2650lp_app.hex
  prebuild: "$XDCROOT$/xs" --xdcpath="$XDCPATH$" iar.tools.configuro -c "$TOOLKIT_DIR$" --cc "$COMPILER_PATH$" --device "$DEVICE$" --compileOptions $COMPILER_ARGS_ROOT_QUOTED$ --linkOptions $LINKER_ARGS_QUOTED$ --profile release --projFile "$PROJ_PATH$"
  ILINK.IlinkOutputFile: multi_role_cc2650lp_app.out
  ILINK.IlinkIcfFile: $SRC_EX$/common/cc26xx/iar/cc26xx_app.icf
  ILINK.IlinkExtraOptions: --keep __vector_table; -f ..\config\configPkg\linker.cmd; -f ..\config\iar_boundary.xcl
  ILINK.IlinkAdditionalLibs: $ROM$\common_rom_releases\03282014\common_rom.symbols; $CC26XXWARE$\driverlib\bin\iar\driverlib.lib
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    $TI_BLE_SDK_BASE$/examples/cc2650iot/target/LAUNCHIOT_CC2650_RGZ/: iotboard_key.c iotboard_key.h
    $TI_BLE_SDK_BASE$/examples/cc2650iot/waist_sensor_master_V2.0/source/app/: multi_role.c multi_role.h
    $TI_BLE_SDK_BASE$/src/common/cc26xx/: util.c util.h
  group Drivers/Display
    $TI_RTOS_DRIVERS_BASE$/ti/mw/display/: Display.c Display.h DisplayUart.c DisplayUart.h
  group Drivers/ECC
    $TI_BLE_SDK_BASE$/src/common/cc26xx/ecc/: ECCROMCC26XX.c ECCROMCC26XX.h
  group Drivers/PIN
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/: PIN.h
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/pin/: PINCC26XX.c PINCC26XX.h
  group Drivers/RF
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/rf/: RF.h RFCC26XX_singleMode.c
  group Drivers/SPI
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/: SPI.c SPI.h
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/spi/: SPICC26XXDMA.c SPICC26XXDMA.h
  group Drivers/TRNG
    $TI_BLE_SDK_BASE$/src/components/hal/src/target/_common/: TRNGCC26XX.c TRNGCC26XX.h
  group Drivers/UDMA
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/dma/: UDMACC26XX.c UDMACC26XX.h
  group GY_SerialPort/GPIO
    $TI_BLE_SDK_BASE$/examples/cc2650iot/waist_sensor_master_V2.0/source/driver/gpio/: hw_gpio.c hw_gpio.h
  group GY_SerialPort/UART
    $TI_BLE_SDK_BASE$/examples/cc2650iot/waist_sensor_master_V2.0/source/driver/uart/: task_uart.c task_uart.h
  group ICall
    $TI_BLE_SDK_BASE$/src/components/heapmgr/: heapmgr.h
    $TI_BLE_SDK_BASE$/src/components/icall/src/: icall.c icall_cc2650.c icall_platform.h
    $TI_BLE_SDK_BASE$/src/components/icall/src/inc/: icall.h
    $TI_BLE_SDK_BASE$/src/icall/inc/: icall_addrs.h
  group ICallBLE
    $TI_BLE_SDK_BASE$/src/icall/app/: ble_user_config-multi_role.c icall_api.c
    $TI_BLE_SDK_BASE$/src/icall/inc/: ble_user_config.h icall_apimsg.h
  group Include
    $TI_BLE_SDK_BASE$/src/profiles/roles/: gapbondmgr.h
    $TI_BLE_SDK_BASE$/src/inc/: gatt.h gattservapp.h hci.h
    $TI_BLE_SDK_BASE$/src/components/osal/src/inc/: osal_snv.h
  group MATRIX
    $TI_BLE_SDK_BASE$/examples/cc2650iot/waist_sensor_master_V2.0/source/matrix/: matrix.c matrix.h
  group Profiles
    $TI_BLE_SDK_BASE$/src/profiles/dev_info/cc26xx/: devinfoservice.c
    $TI_BLE_SDK_BASE$/src/profiles/dev_info/: devinfoservice.h
    $TI_BLE_SDK_BASE$/src/host/: gatt_uuid.c gattservapp_util.c
    $TI_BLE_SDK_BASE$/src/inc/: gatt_uuid.h
    $TI_BLE_SDK_BASE$/src/profiles/roles/cc26xx/: multi.c multi.h
    $TI_BLE_SDK_BASE$/examples/cc2650iot/waist_sensor_master_V2.0/source/profile/: simple_gatt_profile.c simple_gatt_profile.h
  group SDI
    $TI_BLE_SDK_BASE$/examples/cc2650iot/waist_sensor_master_V2.0/source/sdi/: sdi_rxbuf.c sdi_task.c sdi_tl.c sdi_tl_uart.c
  group SPI
    $TI_BLE_SDK_BASE$/examples/cc2650iot/5.16_advance_multirole/source/spi/: bsp.h
    $TI_BLE_SDK_BASE$/examples/cc2650iot/waist_sensor_master_V2.0/source/spi/: bsp_spi.c bsp_spi.h ExtFlash.c ExtFlash.h oad_target.h oad_target_external_flash.c
  group Startup
    $TI_BLE_SDK_BASE$/examples/cc2650iot/target/: board.c
    ../config/: ccfg_app_ble.c
    $TI_BLE_SDK_BASE$/examples/cc2650iot/waist_sensor_master_V2.0/source/app/: main.c
  group TOOLS
    ../config/: app_ble.cfg iar_boundary.bdef iar_boundary.xcl
    $TI_BLE_SDK_BASE$/src/common/cc26xx/iar/: cc26xx_app.icf cc26xx_app_gpram.icf
